#include "sm4.h"

#define ROUND 32

#ifndef GET_ULONG_BE
#define GET_ULONG_BE(n, b, i)                                                 \
  {                                                                           \
    (n) = ((uint32_t)(b)[(i)] << 24) |                                   \
          ((uint32_t)(b)[(i) + 1] << 16) |                               \
          ((uint32_t)(b)[(i) + 2] << 8) | ((uint32_t)(b)[(i) + 3]); \
  }
#endif

#ifndef PUT_ULONG_BE
#define PUT_ULONG_BE(n, b, i)                  \
  {                                            \
    (b)[(i)] = (unsigned char)((n) >> 24);     \
    (b)[(i) + 1] = (unsigned char)((n) >> 16); \
    (b)[(i) + 2] = (unsigned char)((n) >> 8);  \
    (b)[(i) + 3] = (unsigned char)((n));       \
  }
#endif

static const uint8_t sbox[16][16] = {
        {0xd6, 0x90, 0xe9, 0xfe, 0xcc, 0xe1, 0x3d, 0xb7, 0x16, 0xb6, 0x14, 0xc2,
                0x28, 0xfb, 0x2c, 0x05},
        {0x2b, 0x67, 0x9a, 0x76, 0x2a, 0xbe, 0x04, 0xc3, 0xaa, 0x44, 0x13, 0x26,
                0x49, 0x86, 0x06, 0x99},
        {0x9c, 0x42, 0x50, 0xf4, 0x91, 0xef, 0x98, 0x7a, 0x33, 0x54, 0x0b, 0x43,
                0xed, 0xcf, 0xac, 0x62},
        {0xe4, 0xb3, 0x1c, 0xa9, 0xc9, 0x08, 0xe8, 0x95, 0x80, 0xdf, 0x94, 0xfa,
                0x75, 0x8f, 0x3f, 0xa6},
        {0x47, 0x07, 0xa7, 0xfc, 0xf3, 0x73, 0x17, 0xba, 0x83, 0x59, 0x3c, 0x19,
                0xe6, 0x85, 0x4f, 0xa8},
        {0x68, 0x6b, 0x81, 0xb2, 0x71, 0x64, 0xda, 0x8b, 0xf8, 0xeb, 0x0f, 0x4b,
                0x70, 0x56, 0x9d, 0x35},
        {0x1e, 0x24, 0x0e, 0x5e, 0x63, 0x58, 0xd1, 0xa2, 0x25, 0x22, 0x7c, 0x3b,
                0x01, 0x21, 0x78, 0x87},
        {0xd4, 0x00, 0x46, 0x57, 0x9f, 0xd3, 0x27, 0x52, 0x4c, 0x36, 0x02, 0xe7,
                0xa0, 0xc4, 0xc8, 0x9e},
        {0xea, 0xbf, 0x8a, 0xd2, 0x40, 0xc7, 0x38, 0xb5, 0xa3, 0xf7, 0xf2, 0xce,
                0xf9, 0x61, 0x15, 0xa1},
        {0xe0, 0xae, 0x5d, 0xa4, 0x9b, 0x34, 0x1a, 0x55, 0xad, 0x93, 0x32, 0x30,
                0xf5, 0x8c, 0xb1, 0xe3},
        {0x1d, 0xf6, 0xe2, 0x2e, 0x82, 0x66, 0xca, 0x60, 0xc0, 0x29, 0x23, 0xab,
                0x0d, 0x53, 0x4e, 0x6f},
        {0xd5, 0xdb, 0x37, 0x45, 0xde, 0xfd, 0x8e, 0x2f, 0x03, 0xff, 0x6a, 0x72,
                0x6d, 0x6c, 0x5b, 0x51},
        {0x8d, 0x1b, 0xaf, 0x92, 0xbb, 0xdd, 0xbc, 0x7f, 0x11, 0xd9, 0x5c, 0x41,
                0x1f, 0x10, 0x5a, 0xd8},
        {0x0a, 0xc1, 0x31, 0x88, 0xa5, 0xcd, 0x7b, 0xbd, 0x2d, 0x74, 0xd0, 0x12,
                0xb8, 0xe5, 0xb4, 0xb0},
        {0x89, 0x69, 0x97, 0x4a, 0x0c, 0x96, 0x77, 0x7e, 0x65, 0xb9, 0xf1, 0x09,
                0xc5, 0x6e, 0xc6, 0x84},
        {0x18, 0xf0, 0x7d, 0xec, 0x3a, 0xdc, 0x4d, 0x20, 0x79, 0xee, 0x5f, 0x3e,
                0xd7, 0xcb, 0x39, 0x48}};

static const uint8_t fk[4][4] = {{0xa3, 0xb1, 0xba, 0xc6},
                                 {0x56, 0xaa, 0x33, 0x50},
                                 {0x67, 0x7d, 0x91, 0x97},
                                 {0xb2, 0x70, 0x22, 0xdc}};

static const uint8_t ck[32][4] = {
        {0x00, 0x07, 0x0e, 0x15},
        {0x1c, 0x23, 0x2a, 0x31},
        {0x38, 0x3f, 0x46, 0x4d},
        {0x54, 0x5b, 0x62, 0x69},
        {0x70, 0x77, 0x7e, 0x85},
        {0x8c, 0x93, 0x9a, 0xa1},
        {0xa8, 0xaf, 0xb6, 0xbd},
        {0xc4, 0xcb, 0xd2, 0xd9},
        {0xe0, 0xe7, 0xee, 0xf5},
        {0xfc, 0x03, 0x0a, 0x11},
        {0x18, 0x1f, 0x26, 0x2d},
        {0x34, 0x3b, 0x42, 0x49},
        {0x50, 0x57, 0x5e, 0x65},
        {0x6c, 0x73, 0x7a, 0x81},
        {0x88, 0x8f, 0x96, 0x9d},
        {0xa4, 0xab, 0xb2, 0xb9},
        {0xc0, 0xc7, 0xce, 0xd5},
        {0xdc, 0xe3, 0xea, 0xf1},
        {0xf8, 0xff, 0x06, 0x0d},
        {0x14, 0x1b, 0x22, 0x29},
        {0x30, 0x37, 0x3e, 0x45},
        {0x4c, 0x53, 0x5a, 0x61},
        {0x68, 0x6f, 0x76, 0x7d},
        {0x84, 0x8b, 0x92, 0x99},
        {0xa0, 0xa7, 0xae, 0xb5},
        {0xbc, 0xc3, 0xca, 0xd1},
        {0xd8, 0xdf, 0xe6, 0xed},
        {0xf4, 0xfb, 0x02, 0x09},
        {0x10, 0x17, 0x1e, 0x25},
        {0x2c, 0x33, 0x3a, 0x41},
        {0x48, 0x4f, 0x56, 0x5d},
        {0x64, 0x6b, 0x72, 0x79}};


static uint8_t rk[32][4] = {};


void sm4_key_expansion(uint8_t *key) {
    uint8_t mk[4][4] = {};
    uint8_t k[36][4] = {};
    for (int i = 0; i < 16; ++i) {
        mk[i / 4][i % 4] = key[i];
    }
    // for (int i = 0; i < 4; ++i)
    // {
    // 	printf("%hhu, %hhu, %hhu, %hhu\n", mk[i][0], mk[i][1], mk[i][2],
    // mk[i][3]);
    // }

    // init K0 = 0x01234567 ^ 0xa3b1bac6, K1, K2, K3
    for (int i = 0; i < 4; ++i) {
        // printf("K%d ", i);
        for (int j = 0; j < 4; ++j) {
            k[i][j] = mk[i][j] ^ fk[i][j];
            // printf("%x ", k[i][j]);
        }
        // printf("\n");
    }
    for (int i = 0; i < ROUND; ++i) {
        uint8_t temp[4] = {};
        uint32_t res = 0;
        // xor and replace by sbox
        for (int j = 0; j < 4; ++j) {
            uint8_t index = k[i + 1][j] ^k[i + 2][j] ^k[i + 3][j] ^ck[i][j];
            temp[j] = sbox[index / 16][index % 16];
        }

        // printf("Before L:%x %x %x %x\n", temp[0], temp[1], temp[2], temp[3]);
        GET_ULONG_BE(res, temp, 0)
        // printf("Four2One: %u\n", res);
        res = res ^ ((res << 13) | (res >> 19)) ^ ((res << 23) | (res >> 9));
        // printf("AfterShift: %u\n", res);
        PUT_ULONG_BE(res, temp, 0)
        // printf("After L: %x %x %x %x\n", temp[0], temp[1], temp[2], temp[3]);
        for (int l = 0; l < 4; ++l) {
            k[i + 4][l] = k[i][l] ^ temp[l];
            rk[i][l] = k[i + 4][l];
        }
        // printf("%x %x %x %x\n", rk[i][0], rk[i][1], rk[i][2], rk[i][3]);
    }
}

void sm4_cipher(uint8_t *in, uint8_t *out) {
    uint8_t x[36][4] = {};
    for (int i = 0; i < 16; ++i) {
        x[i / 4][i % 4] = in[i];
    }
    for (int i = 0; i < ROUND; ++i) {
        uint8_t temp[4] = {};
        uint32_t res = 0;
        for (int j = 0; j < 4; ++j) {
            uint8_t index = x[i + 1][j] ^x[i + 2][j] ^x[i + 3][j] ^rk[i][j];
            temp[j] = sbox[index / 16][index % 16];
        }
        GET_ULONG_BE(res, temp, 0)
        res = res ^ ((res << 2) | (res >> 30)) ^ ((res << 10) | (res >> 22)) ^
              ((res << 18) | (res >> 14)) ^ ((res << 24) | (res >> 8));
        PUT_ULONG_BE(res, temp, 0)
        // printf("X %d: ", i);
        for (int l = 0; l < 4; ++l) {
            x[i + 4][l] = x[i][l] ^ temp[l];
            // printf("%02x ", x[i + 4][l]);
        }
        // printf("\n");
    }
    for (int i = 0; i < 4; ++i) {
    	for (int j = 0; j < 4; ++j)
    	{
    		out[i*4 + j] = x[35-i][j];
    	}
        // printf("%02x %02x %02x %02x ", x[35 - i][0], x[35 - i][1], x[35 - i][2], x[35 - i][3]);
    }
}
